# Keil uVision project stm32f767ZI.uvprojx, settings and files
target stm32f767ZI (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: stm32f767ZI
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx,__DEBUG
  c include: ../Inc;       ../Drivers/STM32F7xx_HAL_Driver/Inc;       ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;       ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;       ../Middlewares/Third_Party/FatFs/src;       ../Drivers/CMSIS/Include;       ..\..\stm32Common;       ..\..\engine
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group engine
    ../../engine/: ConfigFileManager.cpp ConfigFileManager.h EGDelay.cpp EGDelay.h engine_main.cpp engine_main.h MADSR.cpp MADSR.h SDFileIO.cpp SDFileIO.h SDTest.cpp SDTest.h Voice.cpp Voice.h WaveFile.cpp WaveFile.h
  group common
    ../../stm32Common/: mpr121.c mpr121.h wave_genout.c wave_genout.h wm8978.c wm8978.h
  group Application/User
    ../Src/: stm32f7xx_hal_msp.c sd_diskio.c bsp_driver_sd.c fatfs.c stm32f7xx_it.c main.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal.c stm32f7xx_hal_uart.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_sd.c stm32f7xx_hal_flash.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2s.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_tim.c stm32f7xx_hal_pwr.c stm32f7xx_hal_i2c.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
software components: CMSIS:CORE 4.3.0
