# Keil uVision project stm32f446ze.uvprojx, settings and files
target stm32f446ze (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F446ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: stm32f446ze
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx,__DEBUG
  c include: ../Inc;                      ../Drivers/STM32F4xx_HAL_Driver/Inc;                      ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                      ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                      ../Middlewares/Third_Party/FatFs/src;                      ../Drivers/CMSIS/Include;                      ../../engine;                      ../../stm32Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Application/User
    ../Src/: main.c stm32f4xx_it.c bsp_driver_sd.c fatfs.c stm32f4xx_hal_msp.c sd_diskio.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_rcc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_i2c.c stm32f4xx_hal_gpio.c stm32f4xx_hal.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
  group engine
    ../../engine/: ConfigFileManager.cpp ConfigFileManager.h EGDelay.cpp EGDelay.h engine_main.cpp engine_main.h MADSR.cpp MADSR.h SDFileIO.cpp SDFileIO.h SDTest.cpp SDTest.h Voice.cpp Voice.h WaveFile.cpp WaveFile.h
  group Common
    ../../stm32Common/: mpr121.c wave_genout.c wm8978.c
software components: CMSIS:CORE 4.3.0
